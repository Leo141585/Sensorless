# Keil uVision project ET1202.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ET1202 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group
    ./: STARTUP.A51 XSFR_GLOBAL.c main.c Timer.c OCP.c Eeprom.c WatchDog.c IRDecode.c IPwm.c Pwm.c IIC.c IAE.c Adc.c Motor.c Capture.c LowVoltage.c MCP4728.c CRC.c SleepMode.c Gpio.c CORDIC.c UartSystem.c PI_CTRL.c
  group Include Group
    ./: Adc.h Capture.h CORDIC.h CRC.h DataType.h Eeprom.h ET1202_SFR.h External.h Gpio.h IAE.h IIC.h IPwm.h IRDecode.h LowVoltage.h main.h MCP4728.h Motor.h OCP.h Pwm.h SleepMode.h Timer.h WatchDog.h XSFR_GLOBAL.h UartSystem.H
